##################################################
#  Project         Persistence Management - PCL
#  (c) copyright   2014
#  Company         XS Embedded GmbH
##################################################

require persistence-client-library.inc

PR = "${INC_PR}.1"
PV = "1.0.0+git${SRCPV}"

SRCREV           = "1e13913d57e8ff1bf6faf14465a8555ee459ac6b"
LIC_FILES_CHKSUM = "file://COPYING;md5=6161c6840f21a000e9b52af81d2ca823"


